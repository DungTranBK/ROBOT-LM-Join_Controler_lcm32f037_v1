# Keil uVision project Join_Controler_LCM32F037_V1.uvprojx, settings and files
target Join_Controler_LCM32F037_V1 (6240000::V6.24::ARMCLANG)
  device: LCM32F037 LCMicroelectronics
  pack: Keil.LCM32F0xx_DFP.0.4.72
  cpu: IRAM(0x20000000,0x1000) IROM(0x08001000,0x6C00) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Join_Controler_LCM32F037_V1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;.\SDK\inc
  memory RVCT4: ROM 0x8001000 size 0x6c00
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=6306
  group App
    ./Source/app/: main.c app_isr.c
  group Mid
    ./Source/mid/: control_table.c checksum.c eeprom_store.c foc_math.c motor_ctrl.c motor_monitor.c protocol.c trig_table.c
  group BSP
    ./Source/bsp/: bsp_clock.c bsp_gpio.c bsp_systick.c bsp_system.c bsp_adc.c bsp_opa.c bsp_pwm.c bsp_mt6701.c bsp_mt9102.c bsp_nvic.c bsp_flash.c bsp_bus_uart.c
  group System
    ./Source/system/: system_lcm32f037.c startup_lcm32f037.s
  group SDK
    ./SDK/src/: lcm32f037_rcc.c lcm32f037_tim.c lcm32f037_adc.c lcm32f037_dma.c lcm32f037_opa.c lcm32f037_ssp.c lcm32f037_flash.c lcm32f037_gpio.c lcm32f037_pwr.c
